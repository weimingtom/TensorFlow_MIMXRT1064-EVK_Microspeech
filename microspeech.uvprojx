# Keil uVision project microspeech.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.12.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) IROM2(0x00200000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: microspeech
  c flags: Optim=2 v6Lang=5 v6LangP=6 wLevel=3
  c define: TF_LITE_STATIC_MEMORY
  c include: ./packs/flatbuffers/1.12.0/src/include;./packs/gemmlowp/1.0.0/src;./packs/kissfft/1.3.1/src;./packs/ruy/1.0.0/src;./packs/tensorflow-lite/2.4.0;./packs/tensorflow-lite/2.4.0/tensorflow/lite/;./packs/tensorflow-lite/2.4.0/tensorflow/lite/c;./packs/tensorflow-lite/2.4.0/tensorflow/lite/core/api;./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels;./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal;./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/optimized;./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/reference;./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/reference/integer_ops;./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro;./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/benchmarks;./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/kernels;./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/memory_planner;./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/testing;./packs/tensorflow-lite/2.4.0/tensorflow/lite/schema;./src;./src/i.MXRT
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT5: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ./RTE/Device/MIMXRT1064DVL6A/MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --entry=Reset_Handler --info summarysizes --load_addr_map_info --predefine="-DXIP_BOOT_HEADER_ENABLE=1" --summary_stderr
  group tf_model
    ./src/micro_features/: model.cc
  group tf_output_handler
    ./src/: recognize_commands.cc command_responder.cc
  group application
    ./src/: Platform.c main_functions.cc
  group board
    ./src/i.MXRT/: main.c main.h retarget_stdio.c
  group tf_micro_features
    ./src/micro_features/: micro_features_generator.cc micro_model_settings.cc
  group tf_micro_frontend
    ./src/: feature_provider.cc
    ./src/micro_frontend/lib/: frontend.c frontend_util.c fft.cc filterbank.c log_scale.c noise_reduction.c pcan_gain_control.c window.c fft_util.cc filterbank_util.c log_scale_util.c noise_reduction_util.c pcan_gain_control_util.c window_util.c log_lut.c
  group Audio
    ./: mic_stub.c
  group Test-Mic
    ./src/: audio_provider_test.cc
    ./src/test/: yes_1000ms_sample_data.cc yes_30ms_sample_data.cc no_1000ms_sample_data.cc no_30ms_sample_data.cc
  group Data Processing
    ./packs/kissfft/1.3.1/src/: kiss_fft.c
    ./packs/kissfft/1.3.1/src/tools/: kiss_fftr.c
  group Machine Learning
    ./packs/tensorflow-lite/2.4.0/tensorflow/core/public/: version.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/c/: builtin_op_data.h common.c common.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/core/api/: error_reporter.cc error_reporter.h flatbuffer_conversions.cc flatbuffer_conversions.h op_resolver.cc op_resolver.h profiler.h tensor_utils.cc tensor_utils.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/: common.h compatibility.h cppmath.h max.h min.h portable_tensor.h quantization_util.cc quantization_util.h strided_slice_logic.h tensor_ctypes.h types.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/optimized/: neon_check.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/reference/: add.h arg_min_max.h binary_function.h ceil.h comparisons.h concatenation.h conv.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h floor.h fully_connected.h hard_swish.h l2normalization.h logistic.h maximum_minimum.h mul.h neg.h pad.h pooling.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_nearest_neighbor.h round.h softmax.h strided_slice.h sub.h tanh.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/reference/integer_ops/: add.h conv.h depthwise_conv.h fully_connected.h l2normalization.h logistic.h mul.h pooling.h tanh.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/: kernel_util.cc kernel_util.h op_macros.h padding.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/: all_ops_resolver.cc all_ops_resolver.h compatibility.h debug_log.cc debug_log.h memory_helpers.cc memory_helpers.h micro_allocator.cc micro_allocator.h micro_error_reporter.cc micro_error_reporter.h micro_interpreter.cc micro_interpreter.h micro_mutable_op_resolver.h micro_op_resolver.h micro_optional_debug_tools.cc micro_optional_debug_tools.h micro_profiler.cc micro_profiler.h micro_string.cc micro_string.h micro_time.cc micro_time.h micro_utils.cc micro_utils.h recording_micro_allocator.cc recording_micro_allocator.h recording_micro_interpreter.h recording_simple_memory_allocator.cc recording_simple_memory_allocator.h simple_memory_allocator.cc simple_memory_allocator.h test_helpers.cc test_helpers.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/benchmarks/: keyword_scrambled_model_data.cc keyword_scrambled_model_data.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/kernels/: activation_utils.h activations.cc add.cc arg_min_max.cc ceil.cc circular_buffer.cc comparisons.cc concatenation.cc conv.cc depthwise_conv.cc dequantize.cc elementwise.cc ethosu.cc floor.cc fully_connected.cc hard_swish.cc kernel_runner.cc kernel_runner.h kernel_util.h l2norm.cc logical.cc logistic.cc maximum_minimum.cc micro_ops.h micro_utils.h mul.cc neg.cc pack.cc pad.cc pooling.cc prelu.cc quantize.cc reduce.cc reshape.cc resize_nearest_neighbor.cc round.cc softmax.cc split.cc strided_slice.cc sub.cc svdf.cc tanh.cc unpack.cc
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc greedy_memory_planner.h linear_memory_planner.cc linear_memory_planner.h memory_planner.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/testing/: test_conv_model.cc test_utils.cc
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/: portable_type_to_tflitetype.h version.h
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/schema/: schema_generated.h
  group kernel_util
    ./packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/kernels/: kernel_util.cc
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:VIO:Board 1.0.0, Board Support:SDK Project Template:project_template 1.0.0, Device:CMSIS:MIMXRT1064_header 1.0.0, Device:SDK Drivers:button 1.0.0, Device:SDK Drivers:clock 2.3.2, Device:SDK Drivers:codec 2.1.0, Device:SDK Drivers:codec_i2c 2.1.0, Device:SDK Drivers:common 2.2.2, Device:SDK Drivers:dmamux 2.0.4, Device:SDK Drivers:edma 2.3.0, Device:SDK Drivers:gpio 2.0.3, Device:SDK Drivers:i2c 2.1.10, Device:SDK Drivers:igpio_adapter 1.0.0, Device:SDK Drivers:iomuxc 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpi2c_adapter 1.0.0, Device:SDK Drivers:lpuart 2.2.8, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:pit 2.0.2, Device:SDK Drivers:pit_adapter 1.0.0, Device:SDK Drivers:sai 2.2.2, Device:SDK Drivers:sai_edma 2.2.0, Device:SDK Drivers:timer_manager 1.0.0, Device:SDK Drivers:wm8960 2.1.1, Device:SDK Drivers:wm8960_adapter 2.1.0, Device:SDK Drivers:xip_board 2.0.0, Device:SDK Drivers:xip_device 2.0.0, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup:MIMXRT1064_startup 1.0.0
