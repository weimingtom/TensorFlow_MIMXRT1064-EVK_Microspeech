# Keil uVision project microspeech.uvprojx, settings and files
target Release (6140000::V6.14::ARMCLANG)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.12.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) IROM2(0x00200000,0x020000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: microspeech
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=6 wLevel=1
  c include: ..\src, ..\src\i.MXRT
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT5: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\RTE\Device\MIMXRT1064DVL6A\MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group tf_model
    ../src/: recognize_commands.cc feature_provider.cc
  group tf_output_handler
    ../src/: command_responder.cc
  group application
    ../src/: Platform.c main_functions.cc
  group board
    ../src/i.MXRT/: main.c main.h retarget_stdio.c
  group tf_micro_features
    ../src/micro_features/: micro_features_generator.cc micro_model_settings.cc model.cc no_micro_features_data.cc yes_micro_features_data.cc
  group tf_micro_frontend
    ../src/micro_frontend/: audio_microfrontend.cc
    ../src/micro_frontend/lib/: frontend.c frontend_util.c fft.cc filterbank.c log_scale.c noise_reduction.c pcan_gain_control.c window.c fft_util.cc filterbank_util.c log_scale_util.c noise_reduction_util.c pcan_gain_control_util.c window_util.c log_lut.c
    ../src/: audio_provider.cc audio_provider_test.cc
  group Audio
    ./: mono_mic.c
  group Test
    ../src/test/: yes_1000ms_sample_data.cc yes_30ms_sample_data.cc no_1000ms_sample_data.cc no_30ms_sample_data.cc
    ./: mic_stub.c
target Test (6120000::V6.12 for Armv8.1-M and MVE::.\ARMClang_MVE)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.12.1.0
  cpu: as above
  output: microspeech
  c flags: Optim=2 v6Lang=5 v6LangP=6 wLevel=3
  c include: ..\src, ..\src\i.MXRT
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT5: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\RTE\Device\MIMXRT1064DVL6A\MIMXRT1064xxxxx_flexspi_nor.scf
  link misc: --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:VIO:Board 1.0.0, Data Exchange:Serialization:flatbuffers 1.12.0, Data Processing:Math:gemmlowp fixed-point 1.0.0, Data Processing:Math:kissfft 1.3.1, Data Processing:Math:ruy 1.12.0, Board Support:SDK Project Template:project_template 1.0.0, Device:CMSIS:MIMXRT1064_header 1.0.0, Device:SDK Drivers:button 1.0.0, Device:SDK Drivers:clock 2.3.2, Device:SDK Drivers:codec 2.2.0, Device:SDK Drivers:codec_i2c 2.1.0, Device:SDK Drivers:common 2.2.4, Device:SDK Drivers:dmamux 2.0.4, Device:SDK Drivers:edma 2.3.2, Device:SDK Drivers:gpio 2.0.3, Device:SDK Drivers:i2c 2.1.11, Device:SDK Drivers:igpio_adapter 1.0.0, Device:SDK Drivers:iomuxc 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpi2c_adapter 1.0.0, Device:SDK Drivers:lpuart 2.3.0, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:lpuart_edma 2.3.0, Device:SDK Drivers:pit 2.0.3, Device:SDK Drivers:pit_adapter 1.0.0, Device:SDK Drivers:sai 2.3.1, Device:SDK Drivers:sai_edma 2.3.1, Device:SDK Drivers:timer_manager 1.0.0, Device:SDK Drivers:wm8960 2.1.1, Device:SDK Drivers:wm8960_adapter 2.2.0, Device:SDK Drivers:xip_board 2.0.0, Device:SDK Drivers:xip_device 2.0.0, Device:SDK Project Template:RTE_Device 1.0.0, Device:SDK Utilities:assert 1.0.0, Device:SDK Utilities:debug_console 1.0.0, Device:SDK Utilities:serial_manager 1.0.0, Device:SDK Utilities:serial_manager_uart 1.0.0, Device:Startup:MIMXRT1064_startup 1.1.0, Machine Learning:TensorFlow:Core 2.4.0
